# Keil uVision project template_LL.uvprojx, settings and files
target template_LL (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32H750VBTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x801FFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: template_LL +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: STM32H750xx,USE_FULL_LL_DRIVER,USE_HAL_DRIVER
  c include: ../Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32h750xx.s
  group Application/User
    ../Src/: Led.c Usart1.c Usb.c DMA_ADC_TIM.c Exti_Key.c main.c gpio.c adc.c dma.c tim.c usart.c usb_device.c usbd_conf.c usbd_desc.c usbd_cdc_if.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Drivers/CMSIS
    ../Src/: system_stm32h7xx.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_ll_exti.c stm32h7xx_ll_gpio.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_ll_usb.c stm32h7xx_ll_rcc.c stm32h7xx_ll_utils.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_ll_adc.c stm32h7xx_ll_dma.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_ll_tim.c stm32h7xx_ll_usart.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
software components: CMSIS:CORE 4.3.0
